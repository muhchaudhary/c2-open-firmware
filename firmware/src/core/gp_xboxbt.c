/* gp_xboxbt.c: see gp_xboxbt.h. */
#include "system/includes.h"
#include "gp_xboxbt.h"
#include "gp_leds.h"
#include "gp_rumble.h"
#include "gp_log.h"

/* The Xbox One S (045E:02FD) Bluetooth report descriptor, byte for byte
 * stock's (C2 v3.56, the mode-2 HID record at 0x1E654DB; the same in its
 * L2CAP-search copy): report 1 input (sticks u16, triggers 10 bits, hat, 15
 * buttons, AC Back), 2 input (AC Home: the Xbox button), 3 output (rumble:
 * enable bits, 4 magnitudes, duration, delay, loops), 4 input (battery). */
const u8 xboxbt_report_desc[XBOXBT_REPORT_DESC_LEN] = {
    0x05, 0x01, 0x09, 0x05, 0xa1, 0x01, 0x85, 0x01, 0x09, 0x01, 0xa1, 0x00,
    0x09, 0x30, 0x09, 0x31, 0x15, 0x00, 0x27, 0xff, 0xff, 0x00, 0x00, 0x95,
    0x02, 0x75, 0x10, 0x81, 0x02, 0xc0, 0x09, 0x01, 0xa1, 0x00, 0x09, 0x32,
    0x09, 0x35, 0x15, 0x00, 0x27, 0xff, 0xff, 0x00, 0x00, 0x95, 0x02, 0x75,
    0x10, 0x81, 0x02, 0xc0, 0x05, 0x02, 0x09, 0xc5, 0x15, 0x00, 0x26, 0xff,
    0x03, 0x95, 0x01, 0x75, 0x0a, 0x81, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75,
    0x06, 0x95, 0x01, 0x81, 0x03, 0x05, 0x02, 0x09, 0xc4, 0x15, 0x00, 0x26,
    0xff, 0x03, 0x95, 0x01, 0x75, 0x0a, 0x81, 0x02, 0x15, 0x00, 0x25, 0x00,
    0x75, 0x06, 0x95, 0x01, 0x81, 0x03, 0x05, 0x01, 0x09, 0x39, 0x15, 0x01,
    0x25, 0x08, 0x35, 0x00, 0x46, 0x3b, 0x01, 0x66, 0x14, 0x00, 0x75, 0x04,
    0x95, 0x01, 0x81, 0x42, 0x75, 0x04, 0x95, 0x01, 0x15, 0x00, 0x25, 0x00,
    0x35, 0x00, 0x45, 0x00, 0x65, 0x00, 0x81, 0x03, 0x05, 0x09, 0x19, 0x01,
    0x29, 0x0f, 0x15, 0x00, 0x25, 0x01, 0x75, 0x01, 0x95, 0x0f, 0x81, 0x02,
    0x15, 0x00, 0x25, 0x00, 0x75, 0x01, 0x95, 0x01, 0x81, 0x03, 0x05, 0x0c,
    0x0a, 0x24, 0x02, 0x15, 0x00, 0x25, 0x01, 0x95, 0x01, 0x75, 0x01, 0x81,
    0x02, 0x15, 0x00, 0x25, 0x00, 0x75, 0x07, 0x95, 0x01, 0x81, 0x03, 0x05,
    0x0c, 0x09, 0x01, 0x85, 0x02, 0xa1, 0x01, 0x05, 0x0c, 0x0a, 0x23, 0x02,
    0x15, 0x00, 0x25, 0x01, 0x95, 0x01, 0x75, 0x01, 0x81, 0x02, 0x15, 0x00,
    0x25, 0x00, 0x75, 0x07, 0x95, 0x01, 0x81, 0x03, 0xc0, 0x05, 0x0f, 0x09,
    0x21, 0x85, 0x03, 0xa1, 0x02, 0x09, 0x97, 0x15, 0x00, 0x25, 0x01, 0x75,
    0x04, 0x95, 0x01, 0x91, 0x02, 0x15, 0x00, 0x25, 0x00, 0x75, 0x04, 0x95,
    0x01, 0x91, 0x03, 0x09, 0x70, 0x15, 0x00, 0x25, 0x64, 0x75, 0x08, 0x95,
    0x04, 0x91, 0x02, 0x09, 0x50, 0x66, 0x01, 0x10, 0x55, 0x0e, 0x15, 0x00,
    0x26, 0xff, 0x00, 0x75, 0x08, 0x95, 0x01, 0x91, 0x02, 0x09, 0xa7, 0x15,
    0x00, 0x26, 0xff, 0x00, 0x75, 0x08, 0x95, 0x01, 0x91, 0x02, 0x65, 0x00,
    0x55, 0x00, 0x09, 0x7c, 0x15, 0x00, 0x26, 0xff, 0x00, 0x75, 0x08, 0x95,
    0x01, 0x91, 0x02, 0xc0, 0x05, 0x06, 0x09, 0x20, 0x85, 0x04, 0x15, 0x00,
    0x26, 0xff, 0x00, 0x75, 0x08, 0x95, 0x01, 0x81, 0x02, 0xc0,
};

/* gp_state button -> report 1 button number (1-based, as the descriptor's
 * Button page): 1 A, 2 B, 4 X, 5 Y, 7 LB, 8 RB, 12 Menu, 14 LS, 15 RS (3,
 * 6, 9, 10, 11, 13 unused). As on the real 02FD, View is the AC Back bit
 * after them and the Xbox button only report 2 (AC Home): the Linux
 * mappings (SDL's database, browsers) take them from there. View on Button
 * 11 showed up as an unmapped "button 10"; the Xbox button also on Button
 * 13 pressed Home plus two raw buttons (b12, b16) in SDL. */
volatile u8 xboxbt_guide_dirty;

static const u8 xboxbt_map[][2] = {
    { GP_BTN_SOUTH, 1 }, { GP_BTN_EAST, 2 }, { GP_BTN_WEST, 4 }, { GP_BTN_NORTH, 5 },
    { GP_BTN_L1, 7 }, { GP_BTN_R1, 8 }, { GP_BTN_START, 12 },
    { GP_BTN_L3, 14 }, { GP_BTN_R3, 15 },
};

static void put16(u8 *p, u16 v)
{
    p[0] = (u8)v;
    p[1] = (u8)(v >> 8);
}

/* Hat: 1 N, 2 NE .. 8 NW clockwise, 0 released. */
static u8 xboxbt_hat(u32 b)
{
    static const u8 hat[16] = {
        /* bits: up 1, down 2, left 4, right 8 */
        0, 1, 5, 0, 7, 8, 6, 0, 3, 2, 4, 0, 0, 0, 0, 0,
    };
    u8 i = ((b & GP_BIT(GP_BTN_UP)) ? 1 : 0) | ((b & GP_BIT(GP_BTN_DOWN)) ? 2 : 0) |
           ((b & GP_BIT(GP_BTN_LEFT)) ? 4 : 0) | ((b & GP_BIT(GP_BTN_RIGHT)) ? 8 : 0);
    return hat[i];
}

void xboxbt_encode_state(u8 *rep, const struct gp_state *s)
{
    memset(rep, 0, XBOXBT_REPORT_LEN);
    put16(&rep[0], s->lx + 32768);                      /* sticks: 0..65535, centre 32768, +Y down */
    put16(&rep[2], s->ly + 32768);
    put16(&rep[4], s->rx + 32768);
    put16(&rep[6], s->ry + 32768);
    put16(&rep[8], (u16)(s->lt + 32768) >> 6);          /* triggers: 0..1023 */
    put16(&rep[10], (u16)(s->rt + 32768) >> 6);
    rep[12] = xboxbt_hat(s->buttons);
    u16 b = 0;
    for (int i = 0; i < ARRAY_SIZE(xboxbt_map); i++) {
        if (s->buttons & GP_BIT(xboxbt_map[i][0])) {
            b |= 1u << (xboxbt_map[i][1] - 1);
        }
    }
    put16(&rep[13], b);
    rep[15] = (s->buttons & GP_BIT(GP_BTN_BACK)) ? 1 : 0;      /* AC Back: View (Capture has no 02FD button) */
}

void xboxbt_command(const u8 *c, int len)
{
    /* rumble: enable bits (0 right / weak, 1 left / strong, 2 right
     * trigger, 3 left trigger), magnitudes LT RT left right (0..100),
     * duration and start delay (10 ms), loop count */
    if (len < 8) {
        return;
    }
    u8 en = c[0];
    u32 left = (en & 0x02) ? c[3] : 0, right = (en & 0x01) ? c[4] : 0;
    left = left >= 100 ? 255 : left * 255 / 100;
    right = right >= 100 ? 255 : right * 255 / 100;
    /* duration 0xFF (as SDL sends it) or 0: until the next command; else
     * on for duration x (loops + 1) */
    u32 ms = (c[5] == 0xff || c[5] == 0) ? 0 : (u32)c[5] * 10 * (c[7] + 1);
    gp_rumble_set_timed(left, right, ms);
}
